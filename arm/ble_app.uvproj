# Keil uVision project ble_app.uvproj, settings and files
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_clicky +hex
  c flags: Optim=1 oTime=1 wLevel=2
  c define: NRF51 BOARD_PCA10001 NRF51822_QFAA_FA
  c misc: --c99
  c include: ..\include;..\include\s110
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Startup Code
    ../src/: system_nrf51.c arm_startup_nrf51.s
  group Source Code
    ../src/: main.c
